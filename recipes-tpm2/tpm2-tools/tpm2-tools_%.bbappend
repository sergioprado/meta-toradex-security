RDEPENDS:${PN} = "libtss2 libtss2-mu libtss2-tcti-device libtss2-tcti-mssim"
